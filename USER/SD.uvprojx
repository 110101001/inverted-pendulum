# Keil uVision project SD.uvprojx, settings and files
target SD (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: SD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\MALLOC;..\FWLIB\inc;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\PID;..\HARDWARE\Encoder;..\HARDWARE\MOTOR;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\ANGLE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c ctl.c mode_switch.c
  group HARDWARE
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/Encoder/: Encoder.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/MOTOR/: Motor.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ANGLE/: angle.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_wwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
